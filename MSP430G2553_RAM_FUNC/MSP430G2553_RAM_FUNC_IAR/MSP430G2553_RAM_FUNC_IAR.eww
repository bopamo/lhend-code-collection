<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MSP430G2553_RAM_FUNC_IAR.ewp</path>
  </project>
  <batchBuild/>
</workspace>


